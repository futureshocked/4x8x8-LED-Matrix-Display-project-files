# Repository futureshocked/4x8x8-LED-Matrix-Display-project-files

## KiCad design 4x8x8 LED Matrix Display project files/4x8x8 LED Matrix Clock.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_2.5mm
J1: LED1_IN; PinHeader_1x05_P2.54mm_Vertical
J2: Barrel_Jack; BarrelJack_Horizontal
J3: LED1_OUT; PinHeader_1x05_P2.54mm_Vertical
J4: LED2_IN; PinHeader_1x05_P2.54mm_Vertical
J5: LED2_OUT; PinHeader_1x05_P2.54mm_Vertical
J6: LED3_IN; PinHeader_1x05_P2.54mm_Vertical
J7: LED3_OUT; PinHeader_1x05_P2.54mm_Vertical
J8: LED4_IN; PinHeader_1x05_P2.54mm_Vertical
J9: LED4_OUT; PinHeader_1x05_P2.54mm_Vertical
R1, R2: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
S1, S2: 1825967-1; SW_1825967-1
S3: SS12D07VG4; SW_SS12D07VG4; PARTREV 1
U1: ArduinoProMiniSimple; ArduinoProMiniCustom

Connections:
/CLK0: J1.3, U1.16 (11)
/CLK1: J3.3, J4.3
/CLK2: J5.3, J6.3
/CLK3: J7.3, J8.3
/CS0: J1.1, U1.18 (13)
/CS1: J3.1, J4.1
/CS2: J5.1, J6.1
/CS3: J7.1, J8.1
/DIN0: J1.2, U1.15 (10)
/DIN1: J3.2, J4.2
/DIN2: J5.2, J6.2
/DIN3: J7.2, J8.2
/MODE_SELECT: R2.2, S2.1, S2.2, U1.6 (4)
/TIMER_RESET: R1.2, S1.1, S1.2, U1.7 (5)
/Vcc: J1.5, J2.1, J3.5, J4.5, J5.5, J6.5, J7.5, J8.5, S1.3, S1.4, S2.3, S2.4, U1.29 (VCC)
GND: J1.4, J3.4, J4.4, J5.4, J6.4, J7.4, J8.4, R1.1, R2.1, S3.2, U1.3 (GND), U1.12 (GND), U1.25 (GND), U1.27 (GND), U1.28 (GND)
unnamed: J2.2, S3.3

Notes on the sheet:
ATT: this connector is flipped vertically so that pin numvers correspond correctly accross all headers.

Board: 2 copper layers, 114.9 x 59.7 mm, 19 parts (5 on the bottom side), 17 nets.
